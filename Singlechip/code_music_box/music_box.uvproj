# Keil uVision project music_box.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: music_box +hex
  c flags: Optimize=8 SizeSpeed=1
  group app
    ./: lcd9648.c lcd9648.h font.h MatrixKey.c MatrixKey.h Buzzer.c Buzzer.h mode.c mode.h Timer0.c Timer0.h ired.c ired.h wifi_control.c wifi_control.h uart.c uart.h
  group public
    ./: public.c public.h
  group user
    ./: main.c
